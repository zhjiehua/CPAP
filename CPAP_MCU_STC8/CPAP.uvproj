# Keil uVision project CPAP.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: CPAP +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\HMI;.\HARDWARE;.\PID
  group Source Group 1
    ./: main.c management.c misc.c STARTUP.A51 Conf_tny.A51 readme.txt
  group HMI
    ./HMI/: cmd_process.c cmd_queue.c hmi_driver.c
  group HARDWARE
    ./HARDWARE/: io.c stepmotor.c timer.c uart.c tm770x.c eeprom.c
  group PID
    ./PID/: PID.c
